v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {code_shown.sym} -60 -20 0 0 {name=s1 only_toplevel=false value=".include /home/harry/Work/ECE298A/diff_amp/diff_amp.spice"}
